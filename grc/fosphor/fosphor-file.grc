options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 96e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 50e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/paul/install/grc-install/grc/fm_c96M_s8M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_freq
    freq_span: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
